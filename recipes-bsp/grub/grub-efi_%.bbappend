# SPDX-License-Identifier: MIT

GRUB_BUILDIN:append:comhpc = " tftp efinet gzio"
